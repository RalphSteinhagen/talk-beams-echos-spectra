# experiment 4 (slide `exp6`): the speaker plays a known chirp, 1-8 kHz in 20 ms, once a second; a noise slider buries it
# the matched filter (gr::filter::Correlator against the emitted chirp) compresses microphone 1's chirp to one
# 0.15 ms peak; the trigger watches that peak, so the snapshots keep coming when the chirp has vanished
# in the noise; the ranging left, the four snapshots, the matched filter's output and the waterfall right
blocks:
  - id: opendigitizer::video::BrowserMicrophonePairs
    parameters:
      name: mics # four microphones from two browser stereo sources (devtools/four-mics-browser-pairs.sh)
      pair_a: BEAMS_PAIR_A
      pair_b: BEAMS_PAIR_B
      sample_rate: 48000.0
      align: once
  - id: gr::blocks::fileio::WavSource<float32>
    parameters:
      name: chirp # the known waveform, 1-8 kHz in 20 ms, once a second
      uri: media/chirp-1-8khz.wav
      repeat: true
      trigger_name: ""
  - id: gr::basic::SignalGenerator<float32>
    parameters:
      name: noise # broadband, from the speaker: bury the chirp
      signal_type: GaussianNoise
      amplitude: 0
      sample_rate: 48000
      chunk_size: 480
  - id: gr::blocks::math::Add<float32, std::plus<float32>>
    parameters:
      name: mix
      n_inputs: 2
  - id: gr::audio::AudioSink<float32>
    parameters:
      name: speaker
      req_sample_rate: 48000
      n_inputs: 1
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: noiseLevel
      label: noise
      unit: FS
      value: 0
      min: 0
      max: 0.5
      step: 0.01
      style: slider
      target_map: "noise:amplitude"
  - id: gr::filter::Correlator<float32>
    parameters:
      name: matched # microphone 1 against the emitted chirp: the matched filter
      reference: !!float32 [0, 4.91844e-05, 0.000138356, 0.00025112, 0.00037988, 0.000518236, 0.000660591, 0.000800946, 0.000934104, 0.00105487, 0.00115843, 0.00124001, 0.00129559, 0.00132158, 0.00131518, 0.001274, 0.00119762, 0.00108526, 0.000938103, 0.00075776, 0.000547426, 0.000311101, 5.39829e-05, -0.000217931, -0.000498242, -0.000779753, -0.00105407, -0.00131398, -0.00155031, -0.00175624, -0.00192339, -0.00204615, -0.00211773, -0.00213452, -0.00209294, -0.00199177, -0.00183102, -0.00161269, -0.00134117, -0.00102168, -0.00066259, -0.000272714, 0.000136757, 0.000554624, 0.000967693, 0.00136277, 0.00172665, 0.00204615, 0.00231007, 0.00250681, 0.00262757, 0.00266635, 0.00261797, 0.00248161, 0.00225848, 0.00195378, 0.0015747, 0.00113284, 0.000641397, 0.000115963, -0.000424665, -0.000962095, -0.00147593, -0.00194658, -0.00235525, -0.00268395, -0.00291827, -0.00304623, -0.00305983, -0.00295506, -0.00273233, -0.00239724, -0.00196058, -0.00143674, -0.000844932, -0.000207934, 0.000449058, 0.00109885, 0.00171386, 0.00226688, 0.00273153, 0.00308582, 0.00331135, 0.00339452, 0.00332814, 0.00311141, 0.00275033, 0.00225768, 0.00165348, 0.000962895, 0.000216731, -0.000551425, -0.00130439, -0.00200616, -0.00262117, -0.00311661, -0.0034653, -0.00364684, -0.00364764, -0.0034641, -0.00310102, -0.00257358, -0.001905, -0.00112804, -0.000280711, 0.000593012, 0.00144634, 0.00223249, 0.00290748, 0.00343171, 0.0037724, 0.00390676, 0.00382319, 0.00352168, 0.00301544, 0.00232886, 0.00149872, 0.000571019, -0.000401873, -0.00136237, -0.00225289, -0.00301744, -0.00360766, -0.00398354, -0.00411789, -0.00399753, -0.00362525, -0.00301984, -0.0022153, -0.0012596, -0.000212333, 0.000860127, 0.0018882, 0.00280231, 0.00354008, 0.00404832, 0.00428864, 0.00424026, 0.00390036, 0.00328856, 0.00244163, 0.00141515, 0.000278712, -0.000888918, -0.00200496, -0.00298745, -0.00376321, -0.00427225, -0.00447178, -0.00434222, -0.00388797, -0.00313781, -0.00214292, -0.000976091, 0.000276712, 0.00151992, 0.00265636, 0.00359606, 0.00426105, 0.00459414, 0.00456415, 0.00416748, 0.00343011, 0.00240764, 0.00117843, -0.00015875, -0.00149393, -0.00271634, -0.00372082, -0.0044186, -0.0047465, -0.00467012, -0.00419027, -0.00334214, -0.0021953, -0.000845732, 0.000589413, 0.00198417, 0.00321218, 0.00416068, 0.0047389, 0.00488925, 0.00459134, 0.00386637, 0.00277632, 0.00141755, -8.5173e-05, -0.0015915, -0.00295746, -0.00405032, -0.00476049, -0.00501361, -0.00477888, -0.00407311, -0.00295906, -0.00154271, 3.87877e-05, 0.00162748, 0.00306343, 0.00419747, 0.00490964, 0.00512078, 0.00480288, 0.00398194, 0.00273753, 0.00119562, -0.000483847, -0.00212293, -0.00354608, -0.00459574, -0.00515397, -0.00515317, -0.00458655, -0.00350969, -0.00203615, -0.000325097, 0.00143355, 0.00304224, 0.00431543, 0.00510438, 0.00531232, 0.00490804, 0.00393155, 0.00248961, 0.000746163, -0.00109645, -0.00282031, -0.00421826, -0.00511878, -0.00540789, -0.0050424, -0.00405991, -0.00257358, -0.000761359, 0.00115643, 0.00294147, 0.00436861, 0.00525473, 0.00548066, 0.00501081, 0.00389716, 0.00227568, 0.000351089, -0.00163028, -0.00341012, -0.00475249, -0.00547546, -0.00547626, -0.0047465, -0.00337693, -0.00154471, 0.000506639, 0.00250041, 0.00416308, 0.00526273, 0.00564141, 0.00523834, 0.0041023, 0.00238484, 0.000321898, -0.00179743, -0.00367204, -0.0050312, -0.0056742, -0.00550066, -0.00452736, -0.00288828, -0.000817741, 0.00138396, 0.00339212, 0.00490564, 0.00569339, 0.00562942, 0.0047157, 0.00308182, 0.000970092, -0.00130039, -0.00338173, -0.00495043, -0.00575777, -0.0056702, -0.00469291, -0.00297146, -0.000771355, 0.0015615, 0.00365604, 0.00517316, 0.00586334, 0.00560622, 0.00443539, 0.0025336, 0.000206734, -0.00216451, -0.00418787, -0.00552225, -0.00593892, -0.0053587, -0.00387077, -0.00171985, 0.000733367, 0.00307223, 0.00489285, 0.00587614, 0.00584375, 0.00479328, 0.00289868, 0.000486646, -0.00202176, -0.00418187, -0.00560582, -0.00603249, -0.0053759, -0.00374641, -0.00143035, 0.00115523, 0.00354048, 0.00528432, 0.00606008, 0.00571579, 0.00430623, 0.00208574, -0.00053503, -0.00306503, -0.00502481, -0.00603609, -0.00589893, -0.00462933, -0.00246322, 0.000187541, 0.00281191, 0.00489765, 0.00603169, 0.0059833, 0.00475289, 0.00257478, -0.000124361, -0.00280831, -0.00493803, -0.00607927, -0.0059933, -0.00468811, -0.00242083, 0.000350689, 0.00305983, 0.00514637, 0.00617124, 0.00591373, 0.0044174, 0.00198817, -0.000869324, -0.00355207, -0.00548866, -0.00625962, -0.005691, -0.00389517, -0.001252, 0.00167187, 0.00424106, 0.00589093, 0.00625282, 0.00523714, 0.00305903, 0.000194338, -0.00272274, -0.0050396, -0.00623042, -0.00601889, -0.00444259, -0.00185101, 0.00117123, 0.00393435, 0.00580016, 0.00633199, 0.00539709, 0.00320298, 0.00025352, -0.00276392, -0.00513957, -0.0063072, -0.0059817, -0.00423026, -0.00146274, 0.00166387, 0.00439861, 0.00607767, 0.00628601, 0.00496363, 0.00242403, -0.000717772, -0.00369163, -0.00576057, -0.00640517, -0.00545627, -0.0031402, -2.95906e-05, 0.00309622, 0.00544787, 0.00642316, 0.00576537, 0.00363205, 0.000561422, -0.00266156, -0.00520515, -0.00640517, -0.00594092, -0.00392356, -0.000872523, 0.00241563, 0.00507399, 0.00639437, 0.00601689, 0.00403272, 0.000963295, -0.00237205, -0.00507559, -0.00641157, -0.0060085, -0.00396634, -0.000834136, 0.0025344, 0.00521195, 0.00645475, 0.00590933, 0.00371722, 0.000481447, -0.00289628, -0.00546667, -0.00649914, -0.0056926, -0.00326576, 9.75691e-05, 0.00344051, 0.00580176, 0.00649634, 0.00531312, 0.00258598, -0.000900115, -0.00413029, -0.00615565, -0.00637478, -0.00471251, -0.00165148, 0.0019066, 0.00490285, 0.00643836, 0.00604448, 0.00382919, 0.000452656, -0.00306743, -0.00566101, -0.00653153, -0.00540389, -0.00261357, 0.000987287, 0.00428904, 0.00626601, 0.006296, 0.00435942, 0.00105367, -0.00258918, -0.00542188, -0.00654353, -0.00558983, -0.0028543, 0.000797747, 0.00420027, 0.00625722, 0.0062988, 0.00430184, 0.000904913, -0.00279231, -0.00558263, -0.00654712, -0.0053599, -0.00240244, 0.00135477, 0.00466772, 0.00643076, 0.00604768, 0.00363725, 0, -0.00364245, -0.00605728, -0.00641956, -0.00459654, -0.00120122, 0.00261037, 0.00552985, 0.00654712, 0.00530112, 0.0022149, -0.00164628, -0.00493763, -0.00650434, -0.00578856, -0.00303304, 0.000797747, 0.00435062, 0.00636078, 0.00610486, 0.00366524, -9.23707e-05, -0.00382079, -0.00617444, -0.0062952, -0.00412989, -0.000457855, 0.00338533, 0.0059921, 0.00639917, 0.00444779, 0.000849731, -0.00306703, -0.00584655, -0.00644796, -0.00463733, -0.00108446, 0.00287989, 0.00576057, 0.00646275, 0.00471171, 0.00116443, -0.0028307, -0.00574498, -0.00645395, -0.00467692, -0.00109085, 0.00292107, 0.00580056, 0.00642076, 0.00453136, 0.000863726, -0.0031466, -0.00591852, -0.00635159, -0.00426545, -0.000481447, 0.00349729, 0.00607927, 0.00622403, 0.00386437, -5.59823e-05, -0.00395595, -0.00625282, -0.0060065, -0.00330855, 0.000744964, 0.00449497, 0.00639677, 0.00565901, 0.00257918, -0.0015731, -0.00507199, -0.00645595, -0.00513797, -0.00166307, 0.0025132, 0.00563021, 0.00636598, 0.0044002, 0.000561022, -0.00351848, -0.00609407, -0.00605528, -0.00341092, 0.000705776, 0.00451817, 0.00637118, 0.00545347, 0.00215652, -0.00208414, -0.00541188, -0.00635998, -0.00450377, -0.000656192, 0.0034829, 0.00607447, 0.00595851, 0.00317939, -0.00102448, -0.00476849, -0.00636398, -0.00508479, -0.00150232, 0.00276232, 0.00576937, 0.00614205, 0.00370323, -0.000435462, -0.00437341, -0.0062928, -0.00530072, -0.00184981, 0.00246082, 0.00562382, 0.00615685, 0.00380359, -0.000336693, -0.00431743, -0.00625762, -0.00523354, -0.00172425, 0.00260517, 0.0056898, 0.00605048, 0.00350769, -0.000721371, -0.00460134, -0.00625482, -0.00487565, -0.00112724, 0.003169, 0.00591572, 0.00576337, 0.00278152, -0.0015683, -0.00514197, -0.00617004, -0.00413709, -4.79848e-05, 0.00406311, 0.00614125, 0.00514117, 0.00155911, -0.00280591, -0.00575178, -0.00578457, -0.00288269, 0.00148353, 0.00509039, 0.00609287, 0.00397234, -0.000187541, -0.00424745, -0.00611166, -0.00481167, -0.00101608, 0.00330495, 0.00589933, 0.00540829, 0.00208374, -0.00233206, -0.00551625, -0.00578617, -0.00299465, 0.00138276, 0.00502081, 0.0059793, 0.00374241, -0.000496243, -0.00446458, -0.00602609, -0.00433543, -0.000301904, 0.00389077, 0.00596491, 0.00478808, 0.000998483, -0.00333294, -0.00583135, -0.00511998, -0.0015875, 0.00281791, 0.00565701, 0.0053527, 0.00207014, -0.00236285, -0.00546907, -0.00550625, -0.00245082, 0.00198057, 0.00528792, 0.00559942, 0.00273553, -0.00167907, -0.00513077, -0.00564781, -0.00293187, 0.00146194, 0.00500841, 0.005663, 0.00304543, -0.00133118, -0.00492844, -0.00565301, -0.00308062, 0.00128759, 0.00489445, 0.00562182, 0.00304064, -0.00132958, -0.00490604, -0.00556983, -0.00292507, 0.00145554, 0.00496003, 0.00549266, 0.00273313, -0.00166227, -0.0050492, -0.00538349, -0.00246202, 0.00194538, 0.00516236, 0.00523074, 0.00210773, -0.00229767, -0.00528592, -0.00502121, -0.00166667, 0.00270914, 0.00540029, 0.0047393, 0.00113644, -0.0031654, -0.00548306, -0.00436782, -0.000518236, 0.00364764, 0.00550825, 0.00389077, -0.000182342, -0.00412989, -0.00544627, -0.00329416, 0.000952898, 0.00458055, 0.00526553, 0.00256919, -0.00177224, -0.00496003, -0.00493564, -0.00171586, 0.00260837, 0.00522514, 0.0044302, 0.000744964, -0.00341772, -0.00532711, -0.00373042, 0.000318699, 0.00414549, 0.00521955, 0.0028311, -0.00143115, -0.0047277, -0.00486086, -0.00174425, 0.0025308, 0.00509398, 0.00422226, 0.000507039, -0.00353888, -0.00517636, -0.00329695, 0.000817341, 0.00436142, 0.00491604, 0.00210613, -0.00213812, -0.00489885, -0.00427824, -0.000708575, 0.00333814, 0.0050584, 0.00326177, -0.000797347, -0.00428584, -0.00476809, -0.00191219, 0.00227408, 0.00484686, 0.00399673, 0.000329895, -0.00355567, -0.00490724, -0.00276952, 0.00132958, 0.00446458, 0.00439821, 0.00118402, -0.00286589, -0.00483927, -0.00332015, 0.000587814, 0.00405431, 0.00456895, 0.00176464, -0.00231047, -0.00468411, -0.00362645, 7.99746e-05, 0.00371082, 0.00459894, 0.00209813, -0.00193859, -0.00452377, -0.00374681, -0.000193939, 0.00348609, 0.00455136, 0.0022145, -0.00176664, -0.0044042, -0.00372202, -0.000243523, 0.00340052, 0.00445739, 0.00213652, -0.00179183, -0.00433822, -0.00356927, -8.27738e-05, 0.00344771, 0.00431943, 0.00187341, -0.00199857, -0.00430943, -0.00328256, 0.000275113, 0.00359926, 0.0041107, 0.00142395, -0.00235565, -0.00427424, -0.0028391, 0.000810943, 0.00380159, 0.003784, 0.000785751, -0.00281351, -0.00416428, -0.0022069, 0.00148873, 0.00397594, 0.00327816, -3.11901e-05, -0.00329296, -0.00389317, -0.00136437, 0.00224369, 0.00401793, 0.0025356, -0.000986087, -0.00368243, -0.00336973, -0.000318699, 0.00296826, 0.00380679, 0.00152632, -0.00198657, -0.00384078, -0.0025216, 0.000863326, 0.00350809, 0.00323018, 0.000279511, -0.00287789, -0.00361525, -0.00133598, 0.00203775, 0.00367803, 0.00222369, -0.00108206, -0.00344771, -0.00288908, 0.000100768, 0.00297626, 0.00330495, 0.000828537, -0.00232686, -0.0034701, -0.00164428, 0.0015663, 0.00340332, 0.00230447, -0.000760159, -0.00313741, -0.00278592, -3.4789e-05, 0.00271474, 0.00308182, 0.000771755, -0.00218131, -0.00320019, -0.00141675, 0.0015815, 0.0031582, 0.00194738, -0.000956897, -0.00298105, -0.00235245, 0.000342691, 0.00269754, 0.00263117, 0.000233126, -0.00233686, -0.00278992, -0.000750162, 0.00192779, 0.0028403, 0.00119482, -0.00149513, -0.00279751, -0.00156071, 0.00106126, 0.00267955, 0.00184621, -0.000643396, -0.00250321, -0.00205375, 0.000255519, 0.00228608, 0.00218931, 9.39702e-05, -0.00204295, -0.00226048, -0.000397874, 0.00178823, 0.00227688, 0.000654193, -0.00153231, -0.00224689, -0.000862527, 0.00128479, 0.00218011, 0.00102328, -0.00105247, -0.00208454, -0.00113924, 0.000840134, 0.00196778, 0.00121362, -0.000651393, -0.00183622, -0.00125, 0.000487845, 0.00169386, 0.0012512, -0.000350289, -0.00154431, -0.00122041, 0.000237925, 0.00138956, 0.00115963, -0.000150352, -0.00122881, -0.00106886, 8.55729e-05, 0.00105926, 0.0009461, -4.07871e-05, -0.000873723, -0.000784551, 1.43954e-05, 0.000653793, 0.000559823, -2.39924e-06, -0.000325097, 0]
      lags: 480
  - id: gr::basic::StreamToDataSet<float32>
    parameters:
      name: mfSnapshot
      filter: RISING
      n_pre: 480
      n_post: 1440
      holdoff_samples: 24000
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: mf
      signal_name: "matched filter, mic 1"
      dataset_index: 0
      signal_unit: a.u.
      n_history: 1
      color: 15921906
  - id: gr::blocks::trigger::SchmittTriggerNoInterpolation<float32>
    parameters:
      name: trigger # on the matched filter's output
      threshold: 0.2
      hysteresis: 0.04
      edge: rising
      dead_time: 24000
      trigger_name_rising: RISING
      sample_rate: 48000
  - id: opendigitizer::Arithmetic<float32>
    parameters:
      name: tagOnly # zero, carrying the trigger tag
      operation: "-"
  - id: gr::blocks::math::Add<float32, std::plus<float32>>
    parameters:
      name: tagged0
      n_inputs: 2
  - id: gr::blocks::math::Add<float32, std::plus<float32>>
    parameters:
      name: tagged1
      n_inputs: 2
  - id: gr::blocks::math::Add<float32, std::plus<float32>>
    parameters:
      name: tagged2
      n_inputs: 2
  - id: gr::blocks::math::Add<float32, std::plus<float32>>
    parameters:
      name: tagged3
      n_inputs: 2
  - id: gr::blocks::math::AddConst<float32, std::plus<float32>>
    parameters:
      name: lifted0 # the trace's lift
      value: 0.9
  - id: gr::blocks::math::AddConst<float32, std::plus<float32>>
    parameters:
      name: lifted1 # the trace's lift
      value: 0.3
  - id: gr::blocks::math::AddConst<float32, std::plus<float32>>
    parameters:
      name: lifted2 # the trace's lift
      value: -0.3
  - id: gr::blocks::math::AddConst<float32, std::plus<float32>>
    parameters:
      name: lifted3 # the trace's lift
      value: -0.9
  - id: gr::basic::StreamToDataSet<float32>
    parameters:
      name: snapshot0
      filter: RISING
      n_pre: 480
      n_post: 1440
      holdoff_samples: 24000
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: mic1
      signal_name: mic 1
      dataset_index: 0
      signal_unit: FS
      n_history: 1
      color: 15921906
  - id: gr::basic::StreamToDataSet<float32>
    parameters:
      name: snapshot1
      filter: RISING
      n_pre: 480
      n_post: 1440
      holdoff_samples: 24000
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: mic2
      signal_name: mic 2
      dataset_index: 0
      signal_unit: FS
      n_history: 1
      color: 16626498
  - id: gr::basic::StreamToDataSet<float32>
    parameters:
      name: snapshot2
      filter: RISING
      n_pre: 480
      n_post: 1440
      holdoff_samples: 24000
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: mic3
      signal_name: mic 3
      dataset_index: 0
      signal_unit: FS
      n_history: 1
      color: 2526162
  - id: gr::basic::StreamToDataSet<float32>
    parameters:
      name: snapshot3
      filter: RISING
      n_pre: 480
      n_post: 1440
      holdoff_samples: 24000
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: mic4
      signal_name: mic 4
      dataset_index: 0
      signal_unit: FS
      n_history: 1
      color: 8755456
  - id: DigitizerUi::ImControlNumber
    parameters:
      name: threshold
      label: threshold
      unit: FS
      value: 0.2
      min: 0
      max: 1
      step: 0.01
      style: slider
      target_map: "trigger:threshold"
  - id: gr::blocks::trigger::LevelTrigger<float32>
    parameters:
      name: onset0 # mic 1's hits
      trigger_name: mic 1
      threshold: 0.15
      hysteresis: 0.075
      edge: rising
      dead_time: 24000.0
      dead_time_unit: samples
  - id: gr::blocks::trigger::LevelTrigger<float32>
    parameters:
      name: onset1 # mic 2's hits
      trigger_name: mic 2
      threshold: 0.15
      hysteresis: 0.075
      edge: rising
      dead_time: 24000.0
      dead_time_unit: samples
  - id: gr::blocks::trigger::LevelTrigger<float32>
    parameters:
      name: onset2 # mic 3's hits
      trigger_name: mic 3
      threshold: 0.15
      hysteresis: 0.075
      edge: rising
      dead_time: 24000.0
      dead_time_unit: samples
  - id: gr::blocks::trigger::LevelTrigger<float32>
    parameters:
      name: onset3 # mic 4's hits
      trigger_name: mic 4
      threshold: 0.15
      hysteresis: 0.075
      edge: rising
      dead_time: 24000.0
      dead_time_unit: samples
  - id: gr::blocks::trigger::MultiChannelRecorder<float32>
    parameters:
      name: window # all four channels around a hit
      n_inputs: 4
      n_pre: 480
      n_post: 2400
      retrigger: ignore
      holdoff: 0.5
      emit_partial: false
      history: 0.5
  - id: opendigitizer::localisation::DataSetToTensor<float32>
    parameters:
      name: frames
  - id: gr::localisation::PairCrossCorrelation<float32>
    parameters:
      name: correlation
      max_lag: 450
      weighting: none
      f_min: 100.0
      f_max: 10000.0
  - id: gr::localisation::PairDelay<float32>
    parameters:
      name: delays
      max_lag: 450
  - id: opendigitizer::localisation::PairDelayArrivals<float32>
    parameters:
      name: arrivals
      receiver_names: ["mic 1", "mic 2", "mic 3", "mic 4"]
      min_confidence: 2.0
  - id: opendigitizer::localisation::DelayLocator
    parameters:
      name: locator # the delays of one hit, solved for the drum
      receiver_names: ["mic 1", "mic 2", "mic 3", "mic 4"]
      element_positions: !!float64 [[-1.5, 0.0, 0.0], [-0.5, 0.0, 0.0], [0.5, 0.0, 0.0], [1.5, 0.0, 0.0]]
      roi: [-2.5, 2.5, -0.1, 5.0]
  - id: opendigitizer::ImPlotSink<gr::pmt::ValueMap>
    parameters:
      name: ranged
      signal_name: ranging
      color: 15921906
  - id: gr::blocks::fft::FFT<float32, gr::DataSet<float32>>
    parameters:
      name: FFT
      fft_size: 4096
      sample_rate: 48000
      output_in_db: true
      signal_name: mic 1 spectrum
  - id: opendigitizer::ImPlotSink<gr::DataSet<float32>>
    parameters:
      name: spectrum
      signal_name: mic 1 spectrum
      dataset_index: 0
      abscissa_quantity: frequency
      abscissa_unit: Hz
      signal_quantity: magnitude
      signal_unit: dB
connections:
  - [ chirp, 0, mix, [0, 0] ]
  - [ noise, 0, mix, [0, 1] ]
  - [ mix, 0, speaker, 0 ]
  - [ mics, [0, 0], matched, in ]
  - [ trigger, out, mfSnapshot, in ]
  - [ mfSnapshot, out, mf, in ]
  - [ matched, out, trigger, in ]
  - [ trigger, out, tagOnly, 0 ]
  - [ matched, out, tagOnly, 1 ]
  - [ mics, [0, 0], tagged0, [0, 0] ]
  - [ tagOnly, 0, tagged0, [0, 1] ]
  - [ mics, [0, 1], tagged1, [0, 0] ]
  - [ tagOnly, 0, tagged1, [0, 1] ]
  - [ mics, [0, 2], tagged2, [0, 0] ]
  - [ tagOnly, 0, tagged2, [0, 1] ]
  - [ mics, [0, 3], tagged3, [0, 0] ]
  - [ tagOnly, 0, tagged3, [0, 1] ]
  - [ tagged0, 0, lifted0, 0 ]
  - [ tagged1, 0, lifted1, 0 ]
  - [ tagged2, 0, lifted2, 0 ]
  - [ tagged3, 0, lifted3, 0 ]
  - [ lifted0, 0, snapshot0, in ]
  - [ snapshot0, out, mic1, in ]
  - [ lifted1, 0, snapshot1, in ]
  - [ snapshot1, out, mic2, in ]
  - [ lifted2, 0, snapshot2, in ]
  - [ snapshot2, out, mic3, in ]
  - [ lifted3, 0, snapshot3, in ]
  - [ snapshot3, out, mic4, in ]
  - [ mics, [0, 0], onset0, 0 ]
  - [ onset0, 0, window, 0 ]
  - [ mics, [0, 0], window, [1, 0] ]
  - [ mics, [0, 1], onset1, 0 ]
  - [ onset1, 0, window, 0 ]
  - [ mics, [0, 1], window, [1, 1] ]
  - [ mics, [0, 2], onset2, 0 ]
  - [ onset2, 0, window, 0 ]
  - [ mics, [0, 2], window, [1, 2] ]
  - [ mics, [0, 3], onset3, 0 ]
  - [ onset3, 0, window, 0 ]
  - [ mics, [0, 3], window, [1, 3] ]
  - [ window, 1, frames, 0 ]
  - [ frames, 0, correlation, 0 ]
  - [ correlation, 0, delays, 0 ]
  - [ delays, 0, arrivals, 0 ]
  - [ arrivals, 0, locator, 0 ]
  - [ arrivals, 0, ranged, 0 ]
  - [ locator, 0, ranged, 0 ]
  - [ mics, [0, 0], FFT, 0 ]
  - [ FFT, 0, spectrum, 0 ]
dashboard:
  layout: Free
  windowLayout:
    floatingWindows: { }
    dockSpace:
      hsplit:
        first:
          vsplit:
            first: "Ranging"
            second: "Under the picture"
            ratio: !!float32 0.44
        second:
          vsplit:
            first: "Four microphones, triggered on the matched filter"
            second:
              vsplit:
                first: "Matched filter, mic 1"
                second: "Waterfall, mic 1"
                ratio: !!float32 0.5
            ratio: !!float32 0.6667
        ratio: !!float32 0.3385
  sources:
    - name: mf
      block: mf
    - name: mic1
      block: mic1
    - name: mic2
      block: mic2
    - name: mic3
      block: mic3
    - name: mic4
      block: mic4
    - name: ranged
      block: ranged
    - name: spectrum
      block: spectrum
  plots:
    - name: Ranging
      type: opendigitizer::charts::LocalisationChart
      parameters:
        name: ranging # the `spacing` choice's target
        receiver_names: ["mic 1", "mic 2", "mic 3", "mic 4"]
        element_positions: !!float64 [[-1.5, 0.0, 0.0], [-0.5, 0.0, 0.0], [0.5, 0.0, 0.0], [1.5, 0.0, 0.0]]
        roi: [-2.5, 2.5, -0.1, 5.0]
        show_legend: false
        show_grid: false
        show_curve_labels: false # the drawn map beside it writes the delays
        show_status: true
      sources:
        - ranged
    - name: Under the picture
      type: XYChart
      parameters:
        show_legend: false
      axes:
        - axis: X
          min: 0
          max: 1
        - axis: Y
          min: 0
          max: 1
      sources: []
    - name: Four microphones, triggered on the matched filter
      type: XYChart
      parameters:
        show_legend: false
        show_tags: false
        n_history: 1920
        max_history_count: 1
      axes:
        - axis: X
          min: NaN
          max: NaN
        - axis: Y
          min: -1.4
          max: 1.4
      sources:
        - mic1
        - mic2
        - mic3
        - mic4
    - name: Matched filter, mic 1
      type: XYChart
      parameters:
        show_legend: false
        show_tags: false
        n_history: 1920
        max_history_count: 1
      axes:
        - axis: X
          min: NaN
          max: NaN
        - axis: Y
          min: -0.4
          max: 1.4
      sources:
        - mf
    - name: Waterfall, mic 1
      type: opendigitizer::charts::WaterfallPlot
      parameters:
        show_legend: false
        n_history: 59 # spectra: 5 s at 11.7 a second
        colormap: ImPlotColormap_Viridis
      axes:
        - axis: X
          min: 0
          max: 9700
          scale: Linear
          format: MetricInline
        - axis: Z
          min: -110
          max: -30
      sources:
        - spectrum
